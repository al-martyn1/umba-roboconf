# Keil uVision project 02_i_char_writter.uvproj, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: empty
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F103RC,USE_FULL_ASSERT,UART_N3_ENABLE,USE_HSE,HSE_VALUE=8000000
  c include: .\src\cmsis;.\src;.\src\mcusp;.\src\spl;.\src\modules_config;./src/sfmt/inc
  asm define: STM32F103RC
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group main
    ./src/main/: 02_i_char_writter.cpp
  group umba
    ./src/umba/: critical_section.cpp
  group mcusp
    ./src/mcusp/: system_stm32.c startup_stm32_arm.s
  group retarget
    ./src/retarget/: retarget.cpp
  group spl
    ./src/spl/: stm32_adc.c stm32_aes.c stm32_aes_util.c stm32_bkp.c stm32_can.c stm32_cec.c stm32_comp.c stm32_crc.c stm32_cryp.c stm32_cryp_aes.c stm32_cryp_des.c stm32_cryp_tdes.c stm32_dac.c stm32_dbgmcu.c stm32_dcmi.c stm32_dma.c stm32_dma2d.c stm32_drivers.h stm32_dsi.c stm32_exti.c stm32_flash.c stm32_flash_ramfunc.c stm32_fmc.c stm32_fsmc.c stm32_gpio.c stm32_hash.c stm32_hash_md5.c stm32_hash_sha1.c stm32_hrtim.c stm32_i2c.c stm32_iwdg.c stm32_lcd.c stm32_ltdc.c stm32_misc.c stm32_opamp.c stm32_pwr.c stm32_qspi.c stm32_rcc.c stm32_rng.c stm32_rtc.c stm32_sai.c stm32_sdio.c stm32_spi.c stm32_syscfg.c stm32_tim.c stm32_usart.c stm32_wwdg.c
  group luart
    ./src/luart/: uart_handle.cpp
